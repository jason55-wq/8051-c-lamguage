# Keil uVision project led_C.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: led_C +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    D:/嵌入式系統/8051/lab0_c/: lab0.c
